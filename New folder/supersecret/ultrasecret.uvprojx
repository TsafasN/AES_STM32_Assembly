# Keil uVision project ultrasecret.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ultrasecret +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ../../../../Desktop/: attributes.h tm_stm32f4_usart.c tm_stm32f4_usart.h
    ./: ultrasecret.c aes.s init_aes.s stm32f407vg.h defines.h tm_stm32f4_gpio.c tm_stm32f4_gpio.h
software components: CMSIS:CORE 5.0.0, Device:Startup 2.5.0
